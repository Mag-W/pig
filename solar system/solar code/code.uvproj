# Keil uVision project code.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\PUBLIC;.\ADC;.\AT24C02;.\I2C;.\OLED;.\SERVO
  asm include: .\PUBLIC;.\ADC;.\AT24C02;.\MOTOR;.\OLED;.\I2C
  group MAIN
    ./: STARTUP.A51 main.c
  group I2C
    ./I2C/: i2c.h i2c.c
  group public
    ./PUBLIC/: public.h public.c
  group ADC
    ./ADC/: adc.c adc.h
  group SERVO
    ./SERVO/: servo.c servo.h
  group AT24C02
    ./AT24C02/: 24C02.c 24C02.h
  group OLED
    ./OLED/: oled.c oled_font.h
