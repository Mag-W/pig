# Keil uVision project EXP7.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: EXP7 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\public;.\1602;.\key;.\AD;.\Serial;.\Calculator
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./public/: public.c public.h
    ./key/: key.c key.h
    ./1602/: 1602.c 1602.h
    ./AD/: ad.c ad.h
    ./Calculator/: calculate.c calculate.h
